# Keil uVision project HGB06_1.51_QM.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: HGB06_1.51_QM
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Drivers;..\BSP\Inc;..\Core\Inc;..\Emembed\Inc;..\Middlewares;..\SYSTEM
  group Start
    ./: STARTUP.A51
  group Drivers
    ../Drivers/: STC15W4Kxx.h
  group Core
    ../Core/Src/: adc.c gpio.c main.c timer.c uart.c delay.c
  group Middlewares
    ../Middlewares/: stdint.h stdio.h
  group BSP
    ../BSP/Src/: key.c ntc.c
  group SYSTEM
    ../SYSTEM/: sys.h
  group Emembed
    ../Emembed/Src/: sync.c
